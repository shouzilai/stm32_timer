# IAR project trial.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\App; ..\CMSIS; ..\FWlib\inc; ..\User; ..\CMSIS\startup; ..; ..\User\led; ..\User\key; ..\User\utilities\timer; ..\User\usart; ..\User\utilities\fifo; ..\User\utilities\hup
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: trial.hex
  ILINK.IlinkOutputFile: trial.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup Code
    ../CMSIS/startup/: startup_stm32f10x_cl.s
  group User
    ../User/: common.h main.c stm32f10x_conf.h stm32f10x_it.c
  group User/key
    ../User/key/: key.c
  group User/led
    ../User/led/: led.c
  group User/usart
    ../User/usart/: usart.c
  group User/utilities/fifo
    ../User/utilities/fifo/: ring_buffer_fifo.c
  group User/utilities/hup
    ../User/utilities/hup/: hup.c
  group User/utilities/timer
    ../User/utilities/timer/: timer.c
