# IAR project demo_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105R8 ST STM32F105R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCIncludePath2: User; Std_drive\inc; Std_drive\src; Start_up; APP
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: demo_test.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    APP/: main.c oledfont.h
  group APP/DELAY
    APP/DELAY/: delay.c
  group APP/FIFO
    APP/FIFO/: ring_buffer_fifo.c
  group APP/HUP
    APP/HUP/: hup.c
  group APP/IIC
    APP/IIC/: iic.c oled_iic.c
  group APP/KEY
    APP/KEY/: key.c
  group APP/LED
    APP/LED/: led.c
  group APP/PWM
    APP/PWM/: pwm.c
  group APP/TIM
    APP/TIM/: timer.c
  group APP/USART1
    APP/USART1/: usart.c
  group Start_up
    Start_up/iar/: core_cm3.c core_cm3.h
    Start_up/: startup_stm32f10x_cl.s system_stm32f10x.c system_stm32f10x.h
  group Std_drive
    Std_drive/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    User/: stm32f10x_it.c
